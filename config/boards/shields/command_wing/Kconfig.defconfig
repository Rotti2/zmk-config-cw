## config/boards/shields/command_wing/Kconfig.defconfig
```kconfig
if SHIELD_COMMAND_WING

config ZMK_KEYBOARD_NAME
    default "Command Wing"

endif
```
